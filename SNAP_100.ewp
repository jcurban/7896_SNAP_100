# IAR project SNAP_100.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S007C8 STM8S007C8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S007
  ICCSTM8.CCIncludePath2: .
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: SNAP_100.hex
  ILINK.IlinkOutputFile: SNAP_100.out
  ILINK.IlinkIcfFile: lnkstm8s007C8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 0
  ICCSTM8.CCDefines: NDEBUG; STM8S007
  ILINK.IlinkIcfFile: lnkstm8s007c8.icf
  group (top)
    ./: Device_Serial_Handlers.c GS1011_Serial_Handlers.c main.c ParameterBlockHandlers.c SNAPdata.c SNAPSData.c stm8s_adc1.h stm8s_clk.c stm8s_it.c StringUtilities.c utils.c
